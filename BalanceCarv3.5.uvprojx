# Keil uVision project BalanceCarv3.5.uvprojx, settings and files
target BalanceCar_V3.5 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCarv3.5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWLib\inc;.\FWLib\src;.\HARDWARE;.\MiniBalance;.\SYSTEM;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./CMSIS/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c
  group HARDWARE
    ./HARDWARE/: adc.c encoder.c I2C_Pro.c key.c LED.C motor.c oled.c SIM_IIC.c usart3.c
  group APP
    ./MiniBalance/: control.c DataScope_DP.C filter.c inv_mpu.c inv_mpu_dmp_motion_driver.c show.c MPU6050.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./SYSTEM/: delay.c sys.c usart.c
  group FWlib
    ./FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.0.1
